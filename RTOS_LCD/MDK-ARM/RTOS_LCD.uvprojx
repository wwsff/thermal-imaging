# Keil uVision project RTOS_LCD.uvprojx, settings and files
target RTOS_LCD (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RTOS_LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,SYS_SUPPORT_OS,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Core/BSP/LCD;../Core/mlx90640;../Core/LVGL;../Core/LVGL/src;../Core/LVGL/examples;../Core/LVGL/my_gui_3/custom;../Core/LVGL/my_gui_3/generated;../Core/LVGL/my_gui_3/generated/guider_customer_fonts;../Core/user;../Core/SYSTEM/sys;../Core/SYSTEM/delay;../Core/LVGL/src/draw;../Core/LVGL/examples/porting
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fsmc.c i2c.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP/LCD
    ../Core/BSP/LCD/: lcd.c touch.c
    ../Core/SYSTEM/delay/: delay.c
    ../Core/SYSTEM/sys/: sys.c
  group hardware/MLX90640
    ../Core/mlx90640/: I2C_Drivers.c MLX90640_API.c
  group LVGL/LVGLPort
    ../Core/LVGL/examples/porting/: lv_port_disp.c lv_port_indev.c
  group LVGL/LVGL_Config
    ../Core/LVGL/: lv_conf.h
  group USER/Color
    ../Core/user/: color.c MLX.c cw2015.c boot_screen.c boot_logo.c
  group LVGL/LVGL
    ../Core/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Core/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Core/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Core/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Core/LVGL/src/extra/: lv_extra.c
    ../Core/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../Core/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../Core/LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Core/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../Core/LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../Core/LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../Core/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../Core/LVGL/src/extra/others/msg/: lv_msg.c
    ../Core/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../Core/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../Core/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../Core/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../Core/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../Core/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Core/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../Core/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Core/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Core/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Core/LVGL/src/extra/widgets/led/: lv_led.c
    ../Core/LVGL/src/extra/widgets/list/: lv_list.c
    ../Core/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../Core/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../Core/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Core/LVGL/src/extra/widgets/span/: lv_span.c
    ../Core/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Core/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../Core/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../Core/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../Core/LVGL/src/extra/widgets/win/: lv_win.c
    ../Core/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Core/LVGL/src/draw/nxp/pxp/: lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c lv_draw_pxp_blend.c lv_draw_pxp.c
    ../Core/LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Core/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Core/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Core/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Core/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Core/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Core/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Core/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL/MyGUI
    ../Core/LVGL/my_gui_3/custom/: custom.c
    ../Core/LVGL/my_gui_3/generated/: events_init.c gui_guider.c setup_scr_screen.c widgets_init.c
    ../Core/LVGL/my_gui_3/generated/guider_customer_fonts/: lv_customer_font_SourceHanSansCN_Light_2_12.c lv_customer_font_SourceHanSansCN_Light_2_16.c
    ../Core/LVGL/my_gui_3/generated/guider_fonts/: lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_SourceHanSansCN_Light_2_12.c lv_font_SourceHanSansCN_Light_2_16.c
software components: CMSIS:CORE 4.3.0
